# Keil uVision project Ration_TFT.uvprojx, settings and files
target 瑞生LPC1114 V3.1 (ARM-ADS)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ration_TFT +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\ILI9341;.\LPC11XX;.\MAIN
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group LPC11XX
    ./LPC11XX/: system_LPC11xx.c startup_LPC11xx.s
  group ILI9341
    ./ILI9341/: ili9341.c
  group MAIN
    ./MAIN/: main.c
